File: hw/parts/W5500-EVB-Pico/altium2kicad/wrlshapes.kicad_pcb (KiCad board)
At the start: 10 copper layers, 18 parts

Commit message: w5500-evb-pico footprint
Other:
- net class Default removed
